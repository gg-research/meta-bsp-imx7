PACKAGE_ARCH = "${MACHINE_ARCH}"
RDEPENDS_${PN}_remove = "u-boot-fw-utils"
COMPATIBLE_MACHINE = "cl-som-imx7"
